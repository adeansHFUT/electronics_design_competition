# Keil uVision project diansai.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: diansai +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\Libraries\STM32F10x_StdPeriph_Driver\inc;.\User;.\Libraries\CMSIS;.\Public;.\Peripheral\led;.\Peripheral\OLED;.\Peripheral\pwm;.\Peripheral\time;.\Peripheral\key;.\App\Display;.\RT-Thread\bsp;.\RT-Thread\libcpu\arm\cortex-m3;.\RT-Thread\components\finsh;.\RT-Thread\include;.\RT-Thread\include\libc;.\Peripheral\uart;.\App\Uart_handle
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c include.h board.h
    ./RT-Thread/bsp/: board.c rtconfig.h
  group App
    ./App/Display/: display.c
    ./App/Uart_handle/: uart_handle.c
  group App_h
    ./App/Display/: display.h
    ./App/Uart_handle/: uart_handle.h
  group Rtt_source
    ./RT-Thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Rtt_ports
    ./RT-Thread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group Peripherasl
    ./Peripheral/led/: led.c
    ./Peripheral/OLED/: oled.c
    ./Peripheral/pwm/: pwm.c
    ./Peripheral/time/: time.c
    ./Peripheral/key/: key.c
    ./Peripheral/uart/: bsp_usart.c
  group Peripherasl_h
    ./Peripheral/led/: led.h
    ./Peripheral/OLED/: bmp.h oled.h oledfont.h
    ./Peripheral/pwm/: pwm.h
    ./Peripheral/time/: time.h
    ./Peripheral/key/: key.h
    ./Peripheral/uart/: bsp_usart.h
  group Pubilc
    ./Public/: sys.c sys.h SysTick.c SysTick.h
  group Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c misc.c stm32f10x_dma.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s
  group CMSIS
    ./Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
