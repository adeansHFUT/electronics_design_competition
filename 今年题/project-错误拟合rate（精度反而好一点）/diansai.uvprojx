# Keil uVision project diansai.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: diansai +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\Libraries\STM32F10x_StdPeriph_Driver\inc;.\User;.\Libraries\CMSIS;.\Public;.\Peripheral\led;.\Peripheral\OLED;.\Peripheral\time;.\Peripheral\key;.\App\Display;.\RT-Thread\bsp;.\RT-Thread\libcpu\arm\cortex-m3;.\RT-Thread\components\finsh;.\RT-Thread\include;.\RT-Thread\include\libc;.\Peripheral\uart;.\App\Uart_handle;.\App\Key_handle;.\Peripheral\24Cxx;.\App\Task_tesk;.\Public\iic;.\Public\pwm;.\Public\pid;.\Peripheral\steer;.\App\banqiu_handle;.\App\Ele_gun;.\Peripheral\sr04
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c include.h board.h PORT_cfg.h
    ./RT-Thread/bsp/: board.c rtconfig.h
  group App
    ./App/Display/: display.c
    ./App/Uart_handle/: uart_handle.c
    ./App/Key_handle/: key_handle.c
    ./App/Task_tesk/: task_readAt24c02.c
    ./App/banqiu_handle/: banqiu_handle.c
    ./App/Ele_gun/: Elegun_handle.c
  group App_h
    ./App/Display/: display.h
    ./App/Uart_handle/: uart_handle.h key_handle.h
    ./App/Task_tesk/: task_readAT24c02.h
    ./App/banqiu_handle/: banqiu_handle.h
    ./App/Ele_gun/: Elegun_handle.h
  group Rtt_source
    ./RT-Thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Rtt_ports
    ./RT-Thread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group Peripherasl
    ./Peripheral/uart/: bsp_usart.c
    ./Peripheral/key/: bsp_key.c
    ./Peripheral/led/: bsp_led.c
    ./Peripheral/OLED/: bsp_oled.c
    ./Peripheral/time/: bsp_time.c
    ./Peripheral/24Cxx/: bsp_24cxx.c
    ./Peripheral/steer/: bsp_steer.c
    ./Peripheral/sr04/: bsp_sr04.c
  group Peripherasl_h
    ./Peripheral/OLED/: bmp.h oledfont.h bsp_oled.h
    ./Peripheral/uart/: bsp_usart.h
    ./Peripheral/key/: bsp_key.h
    ./Peripheral/led/: bsp_led.h
    ./Peripheral/time/: bsp_time.h
    ./Peripheral/24Cxx/: bsp_24cxx.h
    ./Peripheral/steer/: bsp_steer.h
    ./Peripheral/sr04/: bsp_sr04.h
  group Pubilc
    ./Public/: sys.c SysTick.c
    ./Public/iic/: bsp_iic.c
    ./Public/pwm/: bsp_pwm.c
    ./Public/pid/: auto_control.c inc_pid_control.c pos_pid_control.c
  group Public_h
    ./Public/: sys.h SysTick.h
    ./Public/pwm/: bsp_pwm.h
    ./Public/iic/: bsp_iic.h
    ./Public/pid/: auto_control.h inc_pid_control.h pos_pid_control.h
  group Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c misc.c stm32f10x_dma.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s
  group CMSIS
    ./Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
